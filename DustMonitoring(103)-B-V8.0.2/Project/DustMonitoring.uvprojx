# Keil uVision project DustMonitoring.uvprojx, settings and files
target DustMonitoring (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DustMonitoring +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User\main;..\User\stm32fxxx;..\User\bsp;..\Libraries\Third_Party\Software\uC-Config;..\Libraries\Third_Party\Software\uC-Config\OS\uCOS-III;..\Libraries\Third_Party\Software\uC-CPU;..\Libraries\Third_Party\Software\uC-CPU\ARM-Cortex-M4\RealView;..\Libraries\Third_Party\Software\uC-LIB;..\Libraries\Third_Party\Software\uCOS-III\Source;..\Libraries\Third_Party\Software\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\User\gprs;..\User\LEDDisplay;..\User\PM25Sensor;..\User\ModbusMaster;..\User\Sensor;..\User\EMQ_inc;..\User\STMFLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group main
    ../User/main/: main.c opt.c app_cfg.h opt.h
  group bsp
    ../User/bsp/: bsp.c bsp.h bsp_debug.h bsp_config_usart.c bsp_config_usart.h bsp_gpio.c bsp_gpio.h bsp_int.c bsp_int.h
  group EMQ
    ../User/gprs/: gprs.c gprs_usart.c gprs.h gprs_usart.h
    ../User/EMQ_scr/: BSP_EMQ.c EMQTT.c sim800c.c sim800c_usart.c timer1.c timer2.c timer3.c timer4.c timer5.c timer6.c
    ../User/STMFLASH/: stmflash.c
  group PM25Sensor
    ../User/PM25Sensor/: pm25_uart3.c pm25_uart3.h
  group Sensor
    ../User/Sensor/: wind_sensor.c wind_sensor.h noise_sensor.c noise_sensor.h
  group ModbusMaster
    ../User/ModbusMaster/: modbus_master.c modbus_uart.c ringbuffer.c trans_recieve_buff_control.c crc16.h modbus_master.h modbus_uart.h ringbuffer.h trans_recieve_buff_control.h word.h
  group LEDDisplay
    ../User/LEDDisplay/: led_display.c led_display.h led_uart1.c led_uart1.h
  group STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_iwdg.c
  group MDK-ARM
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c stm32f10x.h system_stm32f10x.h
  group stm32fxxx
    ../User/stm32fxxx/: stm32f10x_it.c stm32f10x_conf.h stm32f10x_it.h
  group uC-Config
    ../Libraries/Third_Party/Software/uC-Config/: cpu_bsp.c os_app_hooks.c cpu_cfg.h lib_cfg.h os_app_hooks.h os_cfg.h os_cfg_app.h
    ../Libraries/Third_Party/Software/uC-Config/OS/uCOS-III/: bsp_os.c bsp_os.h
  group uC-CPU
    ../Libraries/Third_Party/Software/uC-CPU/: cpu_core.c
    ../Libraries/Third_Party/Software/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group uC-LIB
    ../Libraries/Third_Party/Software/uC-LIB/: lib_ascii.c lib_mem.c lib_str.c
    ../Libraries/Third_Party/Software/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uCOS-III-Source
    ../Libraries/Third_Party/Software/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uCOS-III-Ports
    ../Libraries/Third_Party/Software/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_cpu.h os_cpu_a.asm
